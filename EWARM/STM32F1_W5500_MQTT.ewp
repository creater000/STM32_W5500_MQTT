# IAR project STM32F1_W5500_MQTT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: $PROJ_DIR$; Debug; settings; ..; ..\CMSIS; ..\Manual_Config; ..\Std_Periph; ..\user; ..\ioLibrary_Driver; ..\ioLibrary_Driver\Ethernet; ..\ioLibrary_Driver\Ethernet\W5500; ..\MQTTPacket\src; ..\stdio; ..\ioLibrary_Driver\Internet\DHCP; ..\output_control; ..\processString; ..\uart_debug
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F1_W5500_MQTT.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: settings/stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_cl.s system_stm32f10x.c
  group ioLibrary_Driver/Application/loopback
    ../ioLibrary_Driver/Application/loopback/: loopback.c loopback.h
  group ioLibrary_Driver/Ethernet
    ../ioLibrary_Driver/Ethernet/: socket.c socket.h wizchip_conf.c wizchip_conf.h
  group ioLibrary_Driver/Ethernet/W5500
    ../ioLibrary_Driver/Ethernet/W5500/: w5500.c w5500.h
  group ioLibrary_Driver/Internet/DHCP
    ../ioLibrary_Driver/Internet/DHCP/: dhcp.c dhcp.h
  group ioLibrary_Driver/Internet/DNS
    ../ioLibrary_Driver/Internet/DNS/: dns.c dns.h
  group ioLibrary_Driver/Internet/SNMP
    ../ioLibrary_Driver/Internet/SNMP/: snmp.c snmp.h snmp_custom.c snmp_custom.h
  group ioLibrary_Driver/Internet/SNTP
    ../ioLibrary_Driver/Internet/SNTP/: sntp.c sntp.h
  group MQTTPacket/src
    ../MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group output_control
    ../output_control/: output_control.c output_control.h
  group processString
    ../processString/: process_string.c process_string.h
  group Std_Periph
    ../Std_Periph/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group stdio
    ../stdio/: printf.c
  group uart_config
    ../uart_debug/: uart_debug.c uart_debug.h
  group user
    ./: main.c main.h net_config.h spi_74hc595.c spi_74hc595.h
    ../user/: mqtt_interface.c mqtt_interface.h MQTTClient.c MQTTClient.h W5500HardwareDriver.c W5500HardwareDriver.h
