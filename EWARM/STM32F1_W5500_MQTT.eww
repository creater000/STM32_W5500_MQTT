<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM32F1_W5500_MQTT.ewp</path>
    </project>
    <batchBuild />
</workspace>
